# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group System Calls
    ./: Startup.s Retarget.c
  group Source Code
    ./: Power_management.h main.c Power_management.c boton_eint0.c boton_eint0.h timer0.h timer0.c int_externas_hal.h int_externas_hal.c botones_drv.h botones_drv.c temporizador_hal.h temporizador_hal.c temporizador_drv.h temporizador_drv.c gpio.h io_reserva.h cola_FIFO.h cola_FIFO.c planificador.h planificador.c hello_world.h hello_world.c alarmas.h alarmas.c juego.h juego.c visualizar.h visualizar.c linea_serie_hal.h linea_serie_hal.c linea_serie_drv.h linea_serie_drv.c wd.h wd.c eventos.h llamadas_sistema_hal.h llamadas_sistema_hal.s
  group New Group
    ./: celda.h conecta_K_2023.h conecta_K_2023.c entrada.h tablero.h tablero_test.h config_conecta_K.h entrada.c tablero.c conecta_k_buscar_alineamiento_arm_ambos.s
